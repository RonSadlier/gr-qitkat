<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>example2</value></param>
<param><key>title</key><value>Example 2</value></param>
<param><key>author</key><value>Ronald J Sadlier</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>ber_out</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qitkat_ber_bf</key>
<param><key>id</key><value>qitkat_ber_bf_0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>bit_mask</key><value>255</value></param>
</block>
<block>
<key>qitkat_sdc_encode_bb</key>
<param><key>id</key><value>qitkat_sdc_encode_bb_0</value></param>
<param><key>n</key><value>2</value></param>
</block>
<block>
<key>qitkat_sdc_decode_bb</key>
<param><key>id</key><value>qitkat_sdc_decode_bb_0</value></param>
<param><key>n</key><value>2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>qitkat_bsc_bb</key>
<param><key>id</key><value>qitkat_bsc_bb_0</value></param>
<param><key>error_rate</key><value>0.1</value></param>
<param><key>seed</key><value>1</value></param>
<param><key>bit_mask</key><value>255</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qitkat_ber_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qitkat_ber_bf_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qitkat_sdc_decode_bb_0</source_block_id><sink_block_id>qitkat_ber_bf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>qitkat_bsc_bb_0</source_block_id><sink_block_id>qitkat_sdc_decode_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qitkat_sdc_encode_bb_0</source_block_id><sink_block_id>qitkat_bsc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qitkat_sdc_encode_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
